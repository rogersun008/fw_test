# Keil uVision project LTC_CN.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LTC_CN_XIAN_1.5V_20191017 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;C:\Keil_v5\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c time.c adc.c stm32f0xx_it.c USART1.c dimming_curve.h LTC_IO.c delay.c operation.c operation.h
    ../ST_Lib/inc/: stm32f0xx_wwdg.h stm32f0xx_iwdg.h
    ../ST_Lib/src/: stm32f0xx_wwdg.c stm32f0xx_iwdg.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_exti.c
  group System
    ../System/startup/: startup_stm32f0xx_ld.s
    ../System/CMSIS/: system_stm32f0xx.h core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
